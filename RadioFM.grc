options:
  parameters:
    generate_options: qt_gui
    id: RadioFMMono
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AudioDecimation
  id: variable
  parameters:
    value: '6'
  states: {}
- name: Sintonizador
  id: variable_qtgui_range
  parameters:
    label: Sintonizador
    orient: Qt.Horizontal
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '96600000'
  states: {}
- name: chDecimation
  id: variable
  parameters:
    value: '6'
  states: {}
- name: ch_samp_rate
  id: variable
  parameters:
    value: '288000'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    label: rfGain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1728000'
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    label: volumen
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '2'
    value: '0.5'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:0,0
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '120000'
    decim: chDecimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15500'
    decim: AudioDecimation
    gain: '1'
    samp_rate: ch_samp_rate
    type: fir_filter_fff
    width: '1500'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: Sintonizador
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: Sintonizador
    fftsize: '2048'
    grid: 'True'
    name: Banda FM
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: ch_samp_rate
    fc: '0'
    fftsize: '2048'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '48000'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: FFT
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: ch_samp_rate
    type: float
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', low_pass_filter_1, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_1, '0', analog_fm_deemph_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_2, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
